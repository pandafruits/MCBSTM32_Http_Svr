# Keil uVision project HTTP_Server.uvprojx, settings and files
target MCBSTM32F400 V1.1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=1
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c RTC.c LCD_Sleep.c AM2302.c DWT_Delay.c Core_Temp.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif environment.cgx
  group Documentation
    ./: Abstract.txt
target MCBSTM32F400 V1.2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: HTTP_Server
  c flags: Optim=4
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, Network:CORE 7.4.0, Network:Interface:ETH 7.4.0, Network:Service:Web Server Compact 7.4.0, Network:Socket:TCP 7.4.0, Network:Socket:UDP 7.4.0, CMSIS Driver:Ethernet MAC 2.6, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.1.0, CMSIS Driver:Ethernet PHY:ST802RT1 6.1.0, CMSIS Driver:I2C 2.6, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:RTC 1.6.0, Device:STM32Cube HAL:SRAM 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:Startup 2.6.0
